Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Slidedrain-Sluk90-Klemring.IFC
Time: 2022-10-07T12:46:00
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: BIM-210067-007simple_90 deg exit pipe
In: Default Storey
PredefinedType: ELEMENT; Material: 1.4404
SolidWorks Custom Properties - Date: 07.10.2022; Revision: 01; Tolerance: ISO 2768-mK; Material: 1.4404; Weight: 6089; Weight unit: kg

# IfcBuildingElementProxy: BIM-Joti PURUS rist stål PDM
In: Default Storey
PredefinedType: ELEMENT; Material: 1.4404
SolidWorks Custom Properties - Date: 07.10.2022; Revision: 01; Tolerance: ISO 2768-mK; Material: 1.4404; Weight: 400; Weight unit: kg

# IfcBuildingElementProxy: VannlåsPlaceholdersimple
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcElementAssembly: Slidedrain-Sluk90-Klemring
In: Default Storey
SolidWorks Custom Properties - Date: 07.10.2022; PartNo: 116009-A0; Revision: 01; Tolerance: ISO 2768-mK; Weight: 10916; Weight unit: kg
